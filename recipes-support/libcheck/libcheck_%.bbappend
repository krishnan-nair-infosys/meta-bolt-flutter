#RDEPENDS:checkmk:remove = "gawk"
