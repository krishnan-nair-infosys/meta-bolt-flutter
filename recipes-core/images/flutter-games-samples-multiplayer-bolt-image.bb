SUMMARY = "Flutter sample game app"
#see https://github.com/meta-flutter/meta-flutter/blob/kirkstone/meta-flutter-apps/recipes-graphics/flutter-apps/first-party/flutter-games-samples-multiplayer_0.0.1.bb

inherit base-bolt-image
IMAGE_INSTALL += "flutter-games-samples-multiplayer"

