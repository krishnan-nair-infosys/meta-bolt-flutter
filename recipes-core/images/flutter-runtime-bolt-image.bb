SUMMARY = "Flutter runtime bolt image"

inherit base-bolt-image
IMAGE_INSTALL += "flutter-engine"

