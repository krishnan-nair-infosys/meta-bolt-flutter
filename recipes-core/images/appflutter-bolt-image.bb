SUMMARY = "Flutter App + Flutter runtime bolt image"

inherit base-bolt-image

