
# Add runtime dependency for the cursor library
RDEPENDS:${PN} += "wayland-libs-cursor"
