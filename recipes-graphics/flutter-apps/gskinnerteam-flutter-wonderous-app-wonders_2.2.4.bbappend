S = "${WORKDIR}/git"
#temp workaround for license checksum problem with
#LICENSE = "CLOSED"
#LIC_FILES_CHKSUM = "file://../git/LICENSE;md5=6570d633a333be7d4362fdecbf311bfd"


